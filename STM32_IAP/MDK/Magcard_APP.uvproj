# Keil uVision project Magcard_APP.uvproj, settings and files
target Magcard_IAP (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Magcard +hex
  AfterMake: fromelf.exe --bin -o obj\BinaryOutput\stm32_iap.bin obj\Magcard.axf
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER, USE_STM3210B_EVAL
  c include: ..\user;..\dev;..\lib\inc;..\core_cm3;..\UsbLayer;..\UsbLayer\usblib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c iap.c ini.c delay.c
  group dev
    ../dev/: dev_eprom.c dev_uart.c stm32f10x_it.c
  group lib
    ../lib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_bkp.c stm32f10x_rtc.c
  group core
    ../core_cm3/: core_cm3.c system_stm32f10x.c
    ./startup/: startup_stm32f10x_md.s
  group doc
    ../: readme.txt
  group usb
    ../UsbLayer/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../UsbLayer/usblib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
